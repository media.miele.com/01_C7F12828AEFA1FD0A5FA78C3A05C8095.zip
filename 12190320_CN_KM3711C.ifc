Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 15d47d39-10ce-4723-ab0c-cd4752293e49, NumberOfSaves: 1]
File name: 0001
Time: 2025-09-19T07:02:20+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12190320_CN_KM3711C:26371152_CN_12190320_KM3711C, (2)
In: Default
Type - Material: z_Miele_Design_OBSW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 750 mm; Height: 72 mm; Depth: 430 mm
Classification: E1090320 Uniformat (Uniformat); Material: z_Miele_Design_OBSW, z_Miele_Design_BRWS, <Unnamed>, z_Miele_Design_CLST, z_Miele_Connection_Gas
Pset_BuildingElementProxyCommon - Reference: 26371152_CN_12190320_KM3711C; sets with these values: 2
